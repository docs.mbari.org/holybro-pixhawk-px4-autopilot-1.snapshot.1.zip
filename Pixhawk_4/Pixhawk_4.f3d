Pixhawk_4 (Autodesk Fusion 360 design; units mm, degrees)
named bodies: "Body1", "Body2"